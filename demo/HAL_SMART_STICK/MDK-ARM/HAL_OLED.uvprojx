# Keil uVision project HAL_OLED.uvprojx, settings and files
target HAL_OLED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HAL_OLED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Inc/user;../Core/Inc/user/bsp;../Core/Inc/user/drv;../Core/Inc/user/svc;../Core/Inc/user/app
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Core/Src/: OLED.c Key.c
    ../Core/Inc/: OLED.h OLED_Font.h Key.h
  group System
    ../Core/Src/: Delay.c
    ../Core/Inc/: Delay.h
  group User/Common
    ../Core/Src/user/: cfg.c err.c
  group User/Bsp
    ../Core/Src/user/bsp/: bsp_gpio.c bsp_i2c.c bsp_time.c bsp_uart.c
    ../Core/Inc/user/bsp/: bsp_gpio.h bsp_i2c.h bsp_time.h bsp_uart.h
  group User/Drv
    ../Core/Src/user/drv/: drv_alarm.c drv_batt.c drv_bt.c drv_imu.c drv_key.c drv_mag.c drv_motor.c drv_oled.c drv_us.c
    ../Core/Inc/user/drv/: drv_alarm.h drv_batt.h drv_bt.h drv_imu.h drv_key.h drv_mag.h drv_motor.h drv_oled.h drv_us.h
  group User/Svc
    ../Core/Src/user/svc/: svc_log.c svc_sched.c svc_shell.c
    ../Core/Inc/user/svc/: svc_log.h svc_sched.h svc_shell.h
  group User/App
    ../Core/Src/user/app/: app.c app_ui.c
    ../Core/Inc/user/app/: app.h app_ui.h
software components: CMSIS:CORE 4.3.0
